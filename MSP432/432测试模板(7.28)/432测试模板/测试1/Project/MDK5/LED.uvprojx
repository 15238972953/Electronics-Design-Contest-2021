# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..\..\System;..\..\System\SYS;..\..\System\UART;..\..\System\DELAY;..\..\User;..\..\Libraries;..\..\Libraries\MSP432P4xx;..\..\Libraries\MSP432P4xx\keil;.\RTE\Device;..\..\Hardware;..\..\Hardware\LED;..\..\Hardware\oled;..\..\Hardware\key;..\..\Hardware\MPU6050;..\..\Hardware\MPU6050\eMPL;..\..\Hardware\PID;..\..\Hardware\menu;..\..\Hardware\NRF24L01;..\..\Hardware\SPI;..\..\Hardware\ADC;..\..\Hardware\STEER;..\..\Hardware\Ultrasonic;..\..\Hardware\MORTOR;..\..\Hardware\TIMER;..\..\Hardware\step_cnt;..\..\Hardware\Usart;..\..\Hardware\Openmv;.\Gesture;.\Track;..\..\Hardware\MLX90614_432ver;.\xunji;..\..\Hardware\Encoder
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DRIVELIB
    ../../Libraries/: debug.h driverlib.h eusci.h rom.h rom_map.h
    ../../Libraries/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group HARDWARE
    ../../Hardware/LED/: led.c
    ../../Hardware/oled/: oled.c
    ../../Hardware/key/: key.c
    ../../Hardware/menu/: menu.c
    ../../Hardware/STEER/: steer.c
    ../../Hardware/NRF24L01/: NRF24L01.c
    ../../Hardware/SPI/: SpiDrive.c
    ../../Hardware/ADC/: adc.c
    ../../Hardware/MORTOR/: motor.c
    ../../Hardware/TIMER/: timer.c
    ../../Hardware/step_cnt/: step_cnt.c
    ../../Hardware/Openmv/: openmv.c
    ../../Hardware/MLX90614_432ver/: I2C.c MLX90614.c
    ../../Hardware/Encoder/: Encoder.c
    ../../Hardware/MPU6050/: mpu6050.c mpuiic.c
    ../../Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../Hardware/Ultrasonic/: Ultrasonic.c
  group USER
    ../../User/: main.c
  group PERLIB
    ../../Libraries/MSP432P4xx/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group SYSTEM
    ../../Hardware/Usart/: Usart.c
    ../../System/SYS/: sys.c
    ../../System/DELAY/: Delay.c
  group PROJECT
    ./Gesture/: Gesture.c
    ./Track/: Track.c
    ./xunji/: xunji.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.2
