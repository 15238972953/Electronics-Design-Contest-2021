# Keil uVision project MPU9250.uvprojx, settings and files
target MPU9250 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MPU6050 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\IIC;..\FWLIB\inc;..\HARDWARE\KEY;..\USMART;..\DMP\driver\eMPL;..\DMP\driver\include;..\DMP\driver\stm32L;..\DMP\eMPL-hal;..\DMP\mllite;..\DMP\mpl;..\HARDWARE\MPU9250;..\HARDWARE\OLED;..\HARDWARE\CONTROL;..\HARDWARE\ENCODER;..\HARDWARE\MOTOR;..\HARDWARE\PID;..\HARDWARE\PWM;..\HARDWARE\TIMER;..\HARDWARE\XUNJI;..\HARDWARE\EXTI;..\HARDWARE\DUOJI;..\HARDWARE\DONGZUO;..\HARDWARE\USART3.DMA;..\HARDWARE\USART2.DMA;..\HARDWARE\bujin;..\HARDWARE\USART4.DMA;..\HARDWARE\USART1.DMA;..\HARDWARE\SONIC;..\HARDWARE\FILTER;..\HARDWARE\ADC;..\HARDWARE\NRF24L01;..\HARDWARE\NRF24L01;..\HARDWARE\NRF24L01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MPU9250/: mpu9250.c
    ../HARDWARE/IIC/: mpuiic.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/XUNJI/: xunji.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SONIC/: sonic.c
    ../HARDWARE/FILTER/: filter.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/DUOJI/: duoji.c
    ../HARDWARE/bujin/: bujin.c
    ../HARDWARE/DONGZUO/: dongzuo.c
    ../HARDWARE/USART1.DMA/: usartdma.c
    ../HARDWARE/USART2.DMA/: usart2dma.c
    ../HARDWARE/USART3.DMA/: usart3DMA.c
    ../HARDWARE/USART4.DMA/: usart4dma.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/NRF24L01/: nrf24l01.c spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_spi.c
  group DMP
    ../DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../DMP/driver/stm32L/: log_stm32.c
    ../DMP/eMPL-hal/: eMPL_outputs.c
    ../DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../DMP/mpl/: libmpllib.lib
  group README
    ../: readme.txt
